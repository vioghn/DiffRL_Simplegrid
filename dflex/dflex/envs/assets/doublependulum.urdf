Commit message: double pendulum fix

File: dflex/dflex/envs/assets/doublependulum.urdf (robot description, URDF)
Before this commit: robot physics, 3 links, 3 joints
Joints:
- removed joint base_weld
